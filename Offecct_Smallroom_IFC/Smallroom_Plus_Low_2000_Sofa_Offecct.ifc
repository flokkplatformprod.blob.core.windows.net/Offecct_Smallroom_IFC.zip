Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-03-20T10:03:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 20 10:03:53 2018 * Host: pcz-computer * Database: C:\Users\Paloma\AppData\Local\Temp\{E2377259-2DE9-41ED-8F0F-7D9AD554828D}\ifc * Database version: 5507 * Database creation date: Tue Mar 20 10:03:52 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 20 10:03:52 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 20 10:03:52 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFurnishingElement: Lowroom_2000_Sofa_Offecct, Lowroom_2000_Sofa_Offecct:Lowroom_2000_Sofa_Offecct:321930
In: Level 1
Type - Material: Swing Green 53218, Elmonordic Green, Silver Metal RAL 9006
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Offecct
